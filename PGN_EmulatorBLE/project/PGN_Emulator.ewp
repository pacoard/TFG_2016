# IAR project PGN_Emulator.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../; ../driverlib/MSP430F5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: BCUart.c BCUart.h hal.c hal.h low_level_init.c main.c PGN_protocol.h types.h
  group driverlib/MSP430F5xx_6xx
    ../driverlib/MSP430F5xx_6xx/: dma.c dma.h flash.c flash.h gpio.c gpio.h pmm.c pmm.h sfr.c sfr.h sys.c sys.h timer_b.c timer_b.h tlv.c tlv.h ucs.c ucs.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/inc
    ../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h
